RDEPENDS:${PN} += " \
	nativesdk-python3-crcmod \
"
